# Keil uVision project RealTankSoC.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RealTankSoC
  AfterMake: fromelf -cvf .\RealTankSoC.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\RealTankSoC.axf -o code.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../src/: main.c RealTank.c startup_CMSDK_CM0.s
    ../src/GameSDK/: Game.c
    ../src/Driver/: Buzzer.c code_def.c LCD.c Timer.c UART.c
